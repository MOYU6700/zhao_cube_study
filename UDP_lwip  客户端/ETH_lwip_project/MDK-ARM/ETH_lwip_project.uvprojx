# Keil uVision project ETH_lwip_project.uvprojx, settings and files
target ETH_lwip_project (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ETH_lwip_project +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc;              ../Middlewares/Third_Party/LwIP/src/include;              ../Middlewares/Third_Party/LwIP/system;              ../Drivers/STM32F1xx_HAL_Driver/Inc;              ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;              ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;              ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;              ../Middlewares/Third_Party/LwIP/src/include/lwip;              ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;              ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;              ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;              ../Middlewares/Third_Party/LwIP/src/include/netif;              ../Middlewares/Third_Party/LwIP/src/include/posix;              ../Middlewares/Third_Party/LwIP/src/include/posix/sys;              ../Middlewares/Third_Party/LwIP/system/arch;              ../Drivers/CMSIS/Include;              ..\user_flie
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c
  group Application/User
    ../Src/: lwip.c main.c stm32f1xx_hal_msp.c ethernetif.c stm32f1xx_it.c
    ../user_flie/: app_ethernet.c user_io.c udp_echoclient.c user_uart.c user_timer.c user_spi.c user_config.h spi_lcd.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_frag.c icmp.c igmp.c dhcp.c ip4_addr.c etharp.c ip4.c autoip.c
    ../Middlewares/Third_Party/LwIP/src/core/: init.c netif.c memp.c stats.c tcp_out.c def.c mem.c raw.c pbuf.c sys.c udp.c timeouts.c tcp.c tcp_in.c ip.c dns.c inet_chksum.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: eui64.c chap-md5.c ecp.c pppcrypt.c fsm.c ipv6cp.c pppos.c ppp.c vj.c eap.c upap.c utils.c multilink.c pppoe.c mppe.c chap-new.c pppol2tp.c ipcp.c lcp.c pppapi.c ccp.c demand.c chap_ms.c auth.c magic.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_frag.c ethip6.c nd6.c inet6.c ip6.c mld6.c ip6_addr.c icmp6.c dhcp6.c
    ../Middlewares/Third_Party/LwIP/src/api/: tcpip.c api_lib.c netifapi.c sockets.c netdb.c netbuf.c err.c api_msg.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c lowpan6.c ethernet.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
software components: CMSIS:CORE 4.1.0
