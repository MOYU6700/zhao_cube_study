<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\si4463-stm8s.ewp</path>
  </project>
  <batchBuild/>
</workspace>


