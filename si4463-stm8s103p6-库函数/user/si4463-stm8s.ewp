# IAR project si4463-stm8s.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\si4463-stm8s103p6-库函数\drive\drv_mcu\inc; C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\si4463-stm8s103p6-库函数\drive\drv_periph\inc; C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\si4463-stm8s103p6-库函数\lib\inc; C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\si4463-stm8s103p6-库函数\user\app\inc; C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\si4463-stm8s103p6-库函数\user; C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\si4463-stm8s103p6-库函数\user\app\src; C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\si4463-stm8s103p6-库函数\drive\OLED_SRC
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: si4463-stm8s.hex
  ILINK.IlinkOutputFile: si4463-stm8s.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group drive
    ../drive/drv_mcu/src/: drv_delay.c drv_io.c drv_spi.c drv_uart.c
    ../drive/drv_periph/src/: drv_SI4438.c
    app/src/: modbus_crc.c
    ../drive/OLED_SRC/: oled.c
  group lib
    ../lib/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_it.c stm8s_iwdg.c stm8s_spi.c stm8s_uart1.c
  group user
    ../drive/drv_mcu/src/: iwdg.c user_flash.c
    app/src/: main.c user_config.h
