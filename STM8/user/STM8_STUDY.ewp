# IAR project STM8_STUDY.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\STM8\user; C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\STM8\lib\inc; C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\STM8\lib\src; C:\Users\SHUQUEE8006\Desktop\zhao_cube_study\STM8\drive
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8_STUDY.hex
  ILINK.IlinkOutputFile: STM8_STUDY.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group DRIVE
    ../drive/: led.c stm8s_interrupt.c usart.c
  group LIB
    ../lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_uart1.c
  group USER
    ./: main.c
